# Keil uVision project simpleos.uvproj, settings and files
target Target 1 (MCS-51)
  device: SC51F2832 silan
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0x7FFF) CLOCK(2000000) MODP2
  output: simpleos
  c flags: Optimize=6 SizeSpeed=1
  c include: .\OS;.\APP;.\USER;.\SYS;.\DRIVES
  group OS
    ./OS/: os_cpu.c STARTUPfor2832.A51 OS_CPU_A.asm
  group USER
    ./USER/: main.c os_task.c
  group SYS
    ./SYS/: system.c
  group DRIVES
    ./DRIVES/: lcd_drive.c
